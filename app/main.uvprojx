# Keil uVision project main.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6LangP=1 wLevel=2
  c include: ..\nvic;..\inc;..\timer\timer;..\common;..\gpio;..\interrupt;..\driverlib\driverlib;..\driverlib\inc;..\sysctl
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group app
    ./: main_3.c
  group nvic
    ../nvic/: nvic.c
    ../driverlib/driverlib/: cpu.c
  group timer
    ../timer/: my_timer.c
  group GPIO
    ../gpio/: my_gpio.c
  group intr
    ../interrupt/: my_interrupt.c
  group my_sysctl
    ../sysctl/: my_sysctl.c
  group pwm
    ../driverlib/driverlib/: pwm.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
